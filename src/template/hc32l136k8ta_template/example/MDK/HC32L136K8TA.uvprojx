# Keil uVision project HC32L136K8TA.uvprojx, settings and files
target HC32L136K8TA_Release (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: HC32L136K8TA
  c flags: Optim=1 OneElfS=1
  c include: ..\..\common;..\source
  memory RVCT4: ROM 0x00000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l136k8ta.s
    ../../common/: system_hc32l136k8ta.c
  group source
    ../source/: main.c
software components: CMSIS:CORE 4.1.0
