# Keil uVision project HC32L130J8TA.uvprojx, settings and files
target HC32L130J8TA_Template (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: HC32L136K8TA HDSC
  pack: HDSC.HC32L136.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HC32L130J8TA
  c flags: Optim=1 OneElfS=1
  c include: ..\MDK;..\app;..\Library\common;..\Library\inc;..\rt_thread;..\rt_thread\kernel;..\rt_thread\libcpu\arm\common;..\rt_thread\libcpu\arm\cortex-m0;..\rt_thread\components\finsh;..\rt_thread\include;..\bsp\inc;..\rt_thread\components\drivers\include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group Dirvers
    ../bsp/: board.c bsp_uart.c
  group Applications
    ../app/: startup.c
  group Library
    ./: startup_hc32l130j8ta.s
    ../Library/src/: adc.c adt.c aes.c bgr.c bt.c crc.c ddl.c debug.c dmac.c flash.c gpio.c hdiv.c i2c.c interrupts_hc32l136.c lcd.c lpm.c lpt.c lpuart.c lvd.c opa.c pca.c pcnt.c reset.c rng.c rtc.c spi.c sysctrl.c timer3.c trim.c uart.c vc.c wdt.c
    ../Library/common/: system_hc32l136.c
  group kernel
    ../rt_thread/kernel/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M0
    ../rt_thread/libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
    ../rt_thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../rt_thread/components/drivers/serial/: serial.c
    ../rt_thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../rt_thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
software components: CMSIS:CORE 5.4.0
