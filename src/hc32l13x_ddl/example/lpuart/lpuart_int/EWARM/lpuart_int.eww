<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lpuart_int.ewp</path>
  </project>
  <batchBuild/>
</workspace>


