<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\gt_m1_pwc_oneshot.ewp</path>
  </project>
  <batchBuild/>
</workspace>


