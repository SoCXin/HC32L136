# Keil uVision project timer3_m23_pwm_port_brake.uvprojx, settings and files
target timer3_m23_pwm_port_brake_Release (6100001::V6.10.1::.\ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ESEL ELITTLE
  output: timer3_m23_pwm_port_brake +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l13x.s
    ../../../../mcu/common/: system_hc32l13x.c interrupts_hc32l13x.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c sysctrl.c timer3.c gpio.c flash.c adc.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
